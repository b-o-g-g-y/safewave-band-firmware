# Keil uVision project ble_simple_peripheral.uvproj, settings and files
target ble_simple_peripheral (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: ble_simple_peripheral
  AfterMake: fromelf.exe  --text  -c -o Output/ble_simple_peripheral.txt  Objects/ble_simple_peripheral.axf
  AfterMake: fromelf.exe  --bin -o Output/ble_simple_peripheral.bin  Objects/ble_simple_peripheral.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c misc: --preinclude app_config.h
  c include: ..\..\..\..\components\ble\include;..\..\..\..\components\driver\include;..\..\..\..\components\driver\drv_common;..\..\..\..\components\modules\os\include;..\..\..\..\components\modules\sys\include;..\..\..\..\components\modules\platform\include;..\..\..\..\components\modules\platform\include\cmsis;..\..\..\..\components\modules\common\include;..\..\..\..\components\modules\lowpow\include;..\..\..\..\components\modules\button;..\..\..\..\components\ble\include\gap;..\..\..\..\components\ble\include\gatt;..\..\..\..\components\ble\profiles\ble_simple_profile;..\code;..\..\..\..\components\ble\profiles\ble_ota;..\..\..\..\components\ble\profiles\ble_batt;..\..\..\..\components\ble\profiles\ble_ANCS;..\..\..\..\components\ble\profiles\ble_dev_info;..\code\profile
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x800000
  memory RVCT6: RAM 0x20000000 size 0x80000
  memory RVCT7: RAM 0x40000000 size 0x4000
  memory RVCT8: RAM 0x500f8888 size 0x100
  scatter file: ..\..\..\..\components\toolchain\armcc\fr800x.sct
  link misc: --feedback=feedback.txt ../../../../components/ble/library/syscall.txt --entry=app_main --keep=_jump_table_reserved --keep=_jump_table_version --keep=_jump_table_image --keep=_jump_table_middle --keep=_jump_table_last --datacompressor=off
  group application
    ../code/: proj_main.c ble_simple_peripheral.c device_info_flash.C app_adc.c app_key.c app_pwm.c
    ../code/profile/: ANCS_client.c
  group profiles
    ../code/profile/: band.c ota.c ota_service.c
  group driver
    ../../../../components/driver/: driver_pmu.c driver_gpio.c driver_keyscan.c driver_pwm.c driver_timer.c driver_adc.c driver_efuse.c driver_wdt.c
    ../../../../components/modules/os/include/: os_timer.h
  group platform
    ../../../../components/modules/platform/src/keil/: boot_vectors.s
  group lib
    ../../../../components/ble/library/: fr8000_stack.lib
  group modules
    ../../../../components/modules/common/src/: co_log.c
